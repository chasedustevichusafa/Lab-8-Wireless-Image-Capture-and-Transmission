// Host model for the actual cooperative camera_job.h; faults never touch hardware.
#pragma once
#include "camera_job.h"

class HostCameraHardware {
public:
    HostCameraHardware(std::filesystem::path root, std::string fault) : root_(root), fault_(fault) {
        static const uint8_t jpeg[] = {
            0xff, 0xd8, 0xff, 0xe0, 0x00, 0x10, 0x4a, 0x46, 0x49, 0x46, 0x00, 0x01, 0x01, 0x00, 0x00, 0x01,
            0x00, 0x01, 0x00, 0x00, 0xff, 0xdb, 0x00, 0x43, 0x00, 0x08, 0x06, 0x06, 0x07, 0x06, 0x05, 0x08,
            0x07, 0x07, 0x07, 0x09, 0x09, 0x08, 0x0a, 0x0c, 0x14, 0x0d, 0x0c, 0x0b, 0x0b, 0x0c, 0x19, 0x12,
            0x13, 0x0f, 0x14, 0x1d, 0x1a, 0x1f, 0x1e, 0x1d, 0x1a, 0x1c, 0x1c, 0x20, 0x24, 0x2e, 0x27, 0x20,
            0x22, 0x2c, 0x23, 0x1c, 0x1c, 0x28, 0x37, 0x29, 0x2c, 0x30, 0x31, 0x34, 0x34, 0x34, 0x1f, 0x27,
            0x39, 0x3d, 0x38, 0x32, 0x3c, 0x2e, 0x33, 0x34, 0x32, 0xff, 0xdb, 0x00, 0x43, 0x01, 0x09, 0x09,
            0x09, 0x0c, 0x0b, 0x0c, 0x18, 0x0d, 0x0d, 0x18, 0x32, 0x21, 0x1c, 0x21, 0x32, 0x32, 0x32, 0x32,
            0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32,
            0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32,
            0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0x32, 0xff, 0xc0,
            0x00, 0x11, 0x08, 0x00, 0x10, 0x00, 0x10, 0x03, 0x01, 0x22, 0x00, 0x02, 0x11, 0x01, 0x03, 0x11,
            0x01, 0xff, 0xc4, 0x00, 0x15, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
            0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xff, 0xc4, 0x00, 0x14, 0x10, 0x01, 0x00, 0x00,
            0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xc4,
            0x00, 0x14, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
            0x00, 0x00, 0x00, 0x05, 0xff, 0xc4, 0x00, 0x14, 0x11, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
            0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xff, 0xda, 0x00, 0x0c, 0x03, 0x01,
            0x00, 0x02, 0x11, 0x03, 0x11, 0x00, 0x3f, 0x00, 0x8f, 0x00, 0xc8, 0x67, 0xff, 0xd9,
        };
        image_.assign(jpeg, jpeg+sizeof(jpeg));
        if (fault_ == "camera-fixture") {
            std::ifstream input(root_/"fifo.bin", std::ios::binary);
            image_.assign(std::istreambuf_iterator<char>(input), std::istreambuf_iterator<char>());
        }
        if ((fault_ == "camera-invalid-jpeg" || fault_ == "camera-cleanup-fail")) image_[0] = 0;
    }
    bool ready() const { return fault_ != "camera-absent"; }
    uint32_t mask() const { return ready() ? 0x1fff : 0; }
    const char* reserve(const char* path, const char* temporary) {
        if (fault_ == "camera-sd-absent") return "SD_UNAVAILABLE";
        try {
            std::filesystem::create_directories(root_/"images");
            target_ = root_/(path+1); temporary_ = root_/(temporary+1);
            if (std::filesystem::exists(target_)) return "TARGET_EXISTS";
            if (std::filesystem::exists(temporary_)) return "TEMP_EXISTS";
            file_.open(temporary_, std::ios::binary | std::ios::out | std::ios::trunc);
            position_ = 0;
            return file_ ? nullptr : "CREATE_FAILED";
        } catch (...) { return "CREATE_FAILED"; }
    }
    bool start(unsigned) { ++starts; return fault_ != "camera-start-fail"; }
    int poll(uint32_t& size) { size = fault_ == "camera-too-large" ? kcam::MAX_IMAGE+1 : image_.size(); return fault_ == "camera-timeout" ? 0 : 1; }
    bool space(uint32_t) { return fault_ != "camera-full"; }
    int readCamera(uint8_t* bytes, size_t n) {
        if (fault_ == "camera-read-fail") return -1;
        if (position_+n > image_.size()) return -1;
        memcpy(bytes, image_.data()+position_, n); position_ += n; return (int)n;
    }
    bool writeSD(const uint8_t* bytes, size_t n) {
        if (fault_ == "camera-write-fail") return false;
        file_.write((const char*)bytes, n); return (bool)file_;
    }
    bool prepareVerify(uint32_t) {
        file_.flush(); file_.close();
        if (fault_ == "camera-sync-fail") return false;
        if (fault_ == "camera-corrupt-sd") {
            file_.open(temporary_, std::ios::in | std::ios::out | std::ios::binary);
            file_.put('X'); file_.close();
        }
        file_.clear(); file_.open(temporary_, std::ios::in | std::ios::binary);
        return (bool)file_;
    }
    int readSD(uint8_t* bytes, size_t n) {
        if (fault_ == "camera-verify-fail") return -1;
        file_.read((char*)bytes, n); return (int)file_.gcount();
    }
    bool commit() {
        file_.close();
        if (fault_ == "camera-publish-fail" || std::filesystem::exists(target_)) return false;
        if (::link(temporary_.c_str(), target_.c_str()) != 0) return false;
        return std::filesystem::remove(temporary_);
    }
    bool cleanup() {
        file_.close(); file_.clear();
        if (fault_ == "camera-cleanup-fail") return false;
        return temporary_.empty() || !std::filesystem::exists(temporary_) || std::filesystem::remove(temporary_);
    }
    void stop() {}
    unsigned starts = 0;
private:
    std::filesystem::path root_, target_, temporary_;
    std::string fault_;
    std::fstream file_;
    std::vector<uint8_t> image_;
    size_t position_ = 0;
};
